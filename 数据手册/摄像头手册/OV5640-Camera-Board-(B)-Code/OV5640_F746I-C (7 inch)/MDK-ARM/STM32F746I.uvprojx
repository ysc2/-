# Keil uVision project STM32F746I.uvprojx, settings and files
target STM32F746I (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F746I
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;                    ../Drivers/STM32F7xx_HAL_Driver/Inc;                    ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                    ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                    ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: fmc.c stm32f7xx_hal_msp.c stm32f7xx_it.c gpio.c usart.c dma2d.c main.c ltdc.c dma.c dcmi.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dcmi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group BSP
    ../BSP/: stm32746g_lcd.c stm32746g_sdram.c ov5640.c sccb.c
software components: CMSIS:CORE 4.1.0
